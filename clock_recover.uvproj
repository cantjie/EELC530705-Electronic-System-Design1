# Keil uVision project clock_recover.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: clock_recover
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: clock.c
