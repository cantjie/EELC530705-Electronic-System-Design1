# Keil uVision project frequency_meter.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89V564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: frequency_meter
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 frequency_meter.c
